## nsim/src/isa/npc/Kconfig
```kconfig
menu "ISA-dependent Options for npc"

config RV64
  bool "64-bit RISC-V architecture"
  default n

config RVE
  bool "Use E extension"
  default y
endmenu
```
